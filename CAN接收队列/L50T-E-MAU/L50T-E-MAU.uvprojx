# Keil uVision project L50T-E-MAU.uvprojx, settings and files
target L50T-E-MAU (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: L50T-PDU +hex
  c flags: Optim=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,
  c misc: --c99
  c include: .\CMSIS;.\USER;.\FWlib\src;.\FWlib\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTCODE
    ./STARTCODE/: startup_stm32f10x_md.s
  group USER
    ./USER/: main.c stm32f10x_it.c function.c delay.c
  group FWlib
    ./FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_exti.c
  group CMSIS
    ./CMSIS/CoreSupport/: core_cm3.c
    ./CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
software components: CMSIS:CORE 4.3.0
